# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\Hardware;..\Library;..\Start;..\System;..\User;..\Hardware\BH1750;..\Hardware\DHT11;..\Hardware\Key;..\Hardware\LED;..\Hardware\OLED;..\Hardware\SGP30;..\NET\device;..\NET\MQTT;..\NET\onenet;..\NET\usart;..\System\delay;..\System\sys;..\System\Timer;..\Hardware\Beep
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group Library
    ../Library/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group System
    ../System/delay/: delay.c
    ../System/sys/: sys.c
    ../System/Timer/: timer.c
    ../NET/usart/: usart.c
  group Hardware
    ../Hardware/BH1750/: bh1750.c
    ../Hardware/DHT11/: dht11.c
    ../Hardware/Key/: Key.c
    ../Hardware/LED/: LED.c
    ../Hardware/OLED/: OLED.c
    ../Hardware/SGP30/: sgp30.c
    ../Hardware/Beep/: Beep.c
  group Net
    ../NET/device/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
  group User
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h
